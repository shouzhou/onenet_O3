# Keil uVision project onenetdemo.uvprojx, settings and files
target OneNET_O3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: onenetdemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Hal;..\Devices;..\Network\;..\object;..\Project;..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\CMSIS\startup\arm;..\Protocol\coap_lwm2m\dtls;..\Protocol\coap_lwm2m\lwm2m;..\Protocol\coap_lwm2m\nbiot;..\Protocol\include;..\Protocol\platforms;..\Libraries\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: stm32f10x_it.c main.c
    ../Hal/: menu.c
  group HAL
    ../Protocol/include/: platform.h
    ../Hal/: usart3.c led.c bsp_dht22.c bsp_i2c_gpio.c bsp_iocontrol.c bsp_mkey.c bsp_eeprom_24xx.c bsp_uart_fifo.c bsp_diwen.c bsp_hc.c bsp_tim_capture.c
  group NETWORK
    ../Network/: M5310.c
  group platform
    ../Protocol/platforms/: environment.c memory.c socket.c time.c utils.c
  group COAP
    ../Protocol/coap_lwm2m/: nblist.c node.c observe.c registraction.c transaction.c nbiot.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
    ../Libraries/: fifo.c memb.c ringbuf.c at_cmd.c
software components: CMSIS:CORE 5.2.0
